# Keil uVision project UKU100_7KV.uvproj, settings and files
target 2542+7705 (ARM-ADS)
  device: LPC2119 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: HV7705 +hex
  c flags: Optim=1
  c define: PAROL_ALL_ZERO
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Asm
    ./: Startup.s
  group System
    ./: Timer.c watchdog.c
  group Hardware
    ./: 25lc640.c tlv2542.c pcf8563.c i2c.c ad7705_soft.c lcd_AGM1232_uku100.c lcd_WG12232L3.c
  group Source
    ./: main.c memo.c common_func.c control.c gran.c graphic.c beep.c simbols.c ret.c uart1.c
target 2542+7705_WG12232L3 (ARM-ADS)
  device: LPC2119 NXP (founded by Philips)
  cpu: as above
  output: HV7705_WG12232L3 +hex
  c flags: Optim=1
  c define: PAROL_ALL_ZERO, WG12232L3
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x4000
